<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FA_5510_USB\FA_5510_USB.ewp</path>
  </project>
  <batchBuild/>
</workspace>


