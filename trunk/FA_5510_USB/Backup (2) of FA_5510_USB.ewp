# IAR project Backup (2) of FA_5510_USB.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $PROJ_DIR$; USB_config; F5xx_F6xx_Core_Lib; TI_DriverLib/MSP430F5xx_6xx
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: Driver_User_Interface_For_USB_CDC.c Driver_User_Interface_For_USB_CDC.h FA_MainSystemConfigDefineVarsForFlash.h main.c SystemConfigDefineForFlash.h SystemConfigInitialDataForFlash.s43
  group F5xx_F6xx_Core_Lib
    F5xx_F6xx_Core_Lib/: HAL_FLASH.c HAL_FLASH.h HAL_MACROS.h HAL_PMAP.c HAL_PMAP.h HAL_PMM.c HAL_PMM.h HAL_TLV.c HAL_TLV.h HAL_UCS.c HAL_UCS.h
  group MCU_Devices
    MCU_Devices/: Clock_Config.c I2C_Master.c IO_Config.c MCU_Devices.h Power_Management_Module_Config.c TimerA.c TimerB.c UART_Config.c USB_CDC_Config.c usbConstructs.c usbConstructs.h usbEventHandling.c
  group TI_F5xx_Driver_Lib
    TI_DriverLib/MSP430F5xx_6xx/: gpio.c gpio.h pmm.c pmm.h sfr.c sfr.h timer_a.c timer_a.h timer_b.c timer_b.h ucs.c ucs.h usci_a_uart.c usci_a_uart.h usci_a_uartbaudrate.c usci_a_uartbaudrate.h usci_b_i2c.c usci_b_i2c.h
  group USB_API/USB_CDC_API
    USB_API/USB_CDC_API/: UsbCdc.c UsbCdc.h
  group USB_API/USB_Common
    USB_API/USB_Common/: defMSP430USB.h device.h dma.c types.h usb.c usb.h UsbIsr.h
  group USB_config
    USB_config/: descriptors.c descriptors.h UsbIsr.c
  group Utilities
    Utilities/: CheckSum16.c ModBus_CRC16.c Utilities.h
