# IAR project driverlib.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\; ..\..\..\deprecated\IAR\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  group (top)
    ../: adc10.c adc10.h adc10b.c adc10b.h adc12.c adc12.h adc12b.c adc12b.h aes.c aes.h aes256.c aes256.h bat.c bat.h comp_e.c comp_e.h compb.c compb.h compd.c compd.h crc.c crc.h cs.c cs.h cs_a.c cs_a.h dac12.c dac12.h dma.c dma.h ei2c.c ei2c.h espi.c espi.h euart.c euart.h euart_baudrate.c euart_baudrate.h flash.c flash.h fram.c fram.h frgpio.c frgpio.h frpmm.c frpmm.h gpio.c gpio.h i2c.c i2c.h ldoPwr.c ldoPwr.h mpu.c mpu.h mpu_a.c mpu_a.h mpy32.c mpy32.h pmap.c pmap.h pmm.c pmm.h ramcontroller.c ramcontroller.h ref.c ref.h refa.c refa.h rtc.c rtc.h rtc_c.c rtc_c.h sd24_b.c sd24_b.h sfr_sys.c sfr_sys.h spi.c spi.h tec.c tec.h timer.c timer.h timera.c timera.h timerb.c timerb.h timerd.c timerd.h tlv.c tlv.h uart.c uart.h uart_baudrate.c uart_baudrate.h ucs.c ucs.h wdt.c wdt.h
